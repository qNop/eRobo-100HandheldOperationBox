<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ER-100&#x624B;&#x6301;&#x64CD;&#x4F5C;&#x76D2;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


