# IAR project ER-100手持操作盒.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x50
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: pwm316 AT90PWM316
  ICCAVR.newCCIncludePaths: ..; ..\Doc; ..\Drv\TIME; ..\Drv\UART; ..\Drv\IO; ..\FreeModbus\modbus\rtu; ..\FreeModbus\modbus\include; ..\FreeModbus\modbus\functions; ..\FreeModbus; ..\FreeRTOS_V7.1.1; ..\FreeRTOS_V7.1.1\Source; ..\FreeRTOS_V7.1.1\Source\include; ..\FreeModbus\port; ..\FreeModbus\port\src; ..\Drv\74HC573; ..\Drv\DELAY; ..\Drv\LCD12864; ..\FreeModbus\modbus
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgpwm316.xcl
  XLINK.XExtraOptions: -Ointel-extended,(CODE)=.hex; -Ointel-extended,(XDATA)=.eep
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group APP
    ../: Config.h main.c Menu.c User_Modbus_API.c
  group Doc
    ../Doc/: Default.txt
  group Drv
    ../Drv/DELAY/: delay.h
    ../Drv/IO/: IO_Port.c
    ../Drv/LCD12864/: LCD12864.c
    ../Drv/UART/: portserial.c
    ../Drv/TIME/: porttimer.c
    ../Drv/74HC573/: SN74HC573.c
  group FreeModbus
    ../FreeModbus/modbus/: mb_m.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu_m.c
    ../FreeModbus/modbus/functions/: mbfuncholding_m.c mbutils.c
    ../FreeModbus/port/: port.h
    ../FreeModbus/port/src/: portevent_m.c
  group FreeRTOS
    ../FreeRTOS_V7.1.1/: FreeRTOSConfig.h
    ../FreeRTOS_V7.1.1/Source/portable/MemMang/: heap_1.c
    ../FreeRTOS_V7.1.1/Source/: list.c queue.c tasks.c
    ../FreeRTOS_V7.1.1/Source/portable/IAR/ATMega323/: port.c portmacro.s90
